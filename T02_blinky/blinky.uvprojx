# Keil uVision project blinky.uvprojx, settings and files
target Target-LPC1311FHN33 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1311FHN33 NXP
  pack: Keil.LPC1300_DFP.1.0.0
  cpu: IROM(0x00000000,0x2000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x2000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Source Files
    ./: main.c
  group Peripheral Files
    ./: gpio.h gpio.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
