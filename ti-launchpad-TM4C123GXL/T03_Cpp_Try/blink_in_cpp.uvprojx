# Keil uVision project blink_in_cpp.uvprojx, settings and files
target TM4C123GH6PM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blink_in_cpp
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --C99 --cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Files
    ./: blink.cpp
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
