# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAM3X8E Atmel
  pack: Keil.SAM3_DFP.1.0.1
  cpu: IROM(0x00080000,0x40000) IROM2(0x000C0000,0x40000) IRAM(0x20000000,0x10000) IRAM2(0x20080000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x80000 size 0x40000
  memory RVCT5: ROM 0xc0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20080000 size 0x8000
  group Source Group 1
    ./: blink.c hw_led.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
